# Keil uVision project LKS32MC074DX.uvprojx, settings and files
target lks32mc07x_StdPeriph (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC071CBT8 Linko
  pack: Linko.LKS07x.1.2.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS32MC074DX_LKSConfig_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Mcu\mc07x\Include;..\Mcu\mc07x\lks32mc07x_periph_driver\include;..\Mcu\mc07x\SEGGER_RTT
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: ..\Mcu\mc07x\LKS32MC074DX_LKSConfig_Project.sct
  group Source
    ../Mcu/mc07x/Source/: delay.c hardware_init.c interrupt.c main.c
    ../Mcu/mc07x/Include/: delay.h hardware_config.h hardware_init.h interrupt.h
  group Periph_drivers
    ../Mcu/mc07x/lks32mc07x_periph_driver/source/: lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_clu.c lks32mc07x_cmp.c lks32mc07x_crc.c lks32mc07x_dac.c lks32mc07x_dma.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32mc07x_flash.c lks32mc07x_gpio.c lks32mc07x_hall.c lks32mc07x_i2c.c lks32mc07x_mcpwm.c lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_spi.c lks32mc07x_sys.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_uart.c lks32mc07x_wake.c lks32mc07x_nvr.lib startup_lks32mc07x.s
  group SEGGER_RTT
    ../Mcu/mc07x/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c rtt_debug.h SEGGER_RTT.h SEGGER_RTT_Conf.h
software components: CMSIS:CORE 5.5.0
